# Keil uVision project balloon.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: balloon +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user_files
  group Source Group 1
    ./: STARTUP.A51
    ../user_files/: main.c Stc12c5a.h IO.c IO.h Timer.c Timer.h Global.c Global.h UserTask.c EEProm.c EEProm.h ISR.c CommuTask.c CommuTask.h MC20.c MC20.h REG51.H REG52.H DS18B20.c DS18B20.h
